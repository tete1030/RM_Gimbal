# Keil uVision project STM32F4.uvproj, settings and files
target STM32F4 (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F4
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries;..\User;..\BSP;..\MPU6050;..\HMC5883
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: stm32f4xx_it.c app.c app.h global_define.h global_varialbe.c main.c main.h Imu.c
  group MPU6050
    ../MPU6050/: mpu6050_driver.c mpu6050_driver.h mpu6050_i2c.c mpu6050_i2c.h mpu6050_interrupt.c mpu6050_interrupt.h
  group BSP
    ../BSP/: bsp.c bsp.h can1.c can1.h can2.c can2.h usart1.c usart1.h delay.c delay.h tim6.c tim6.h led.c led.h laser.c laser.h usart2.c usart2.h pwm.c pwm.h
  group Libraries
    ../Libraries/: misc.c stm32f4xx_tim.c stm32f4xx_rcc.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_syscfg.c system_stm32f4xx.c startup_stm32f4xx.s stm32f4xx_i2c.c stm32f4xx_wwdg.c stm32f4xx_flash.c stm32f4xx_dma.c
